# Keil uVision project OsekIntroII_Example6.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OsekIntro_Example6
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: ..\..\oil;..\..\OsekLib;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\Common;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\RTE;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\SWC\EngineTemperatureControl;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\SWC\EngineTemperatureSensor;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\SWC\NVBlock;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\SWC\Parameter;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\BSW\ECU_Abstraction;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\BSW\MCAL;D:\Mock_Autosar_Project_V6_3\EngineCoolingSystem\ECU1\BSW\Services
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source group1
    ../../OsekLib/: hook.c counter.c counter.h os.h OsekLib.lib OsTypes.h
    ../../OsekLib/startup/: keilUvisoin_startup.s
    ../../oil/: OsCfg.c OsCfg.h
    ./: OsekIntroII_Example6.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/BSW/ECU_Abstraction/: CanIf.c IoHwAb_AirTempSensor.c IoHwAb_EngineTempSensor.c WdgIf.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/BSW/MCAL/: Adc.c Can.c Det.c Wdg.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/BSW/Services/: Com.c Dcm.c Dem.c Nvm.c PDU_R.c WdgM.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/RTE/: Rte_EngineTemperatureControl.c Rte_EngineTemperatureSensor.c Rte_NVBlock.c Rte_Parameter.c Rte_Wdg.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/SWC/EngineTemperatureControl/: EngineTemperatureControl.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/SWC/EngineTemperatureSensor/: EngineTemperatureSensor.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/SWC/NVBlock/: NVBlock.c
    D:/Mock_Autosar_Project_V6_3/EngineCoolingSystem/ECU1/SWC/Parameter/: Parameter.c
software components: CMSIS:CORE 5.6.0

# Keil uVision project OsekIntroII_Example5.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OsekIntro_Example5
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c include: ..\..\oil;..\..\OsekLib;..\OsekIntroII_Example1;..\..\..\..\..\Mock_Autosar_Project\EngineCoolingSystem\ECU2\BSW\ECU_Abstraction;..\..\..\..\..\Mock_Autosar_Project\EngineCoolingSystem\ECU2\BSW\MCAL;..\..\..\..\..\Mock_Autosar_Project\EngineCoolingSystem\ECU2\BSW\Services;..\..\..\..\..\Mock_Autosar_Project\EngineCoolingSystem\ECU2\common;..\..\..\..\..\Mock_Autosar_Project\EngineCoolingSystem\ECU2\RTE;..\..\..\..\..\Mock_Autosar_Project\EngineCoolingSystem\ECU2\SWC;..\..\..\..\..\Mock_Autosar_Project\EngineCoolingSystem\ECU1\BSW\Services
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../../oil/: OsCfg.c OsCfg.h
    ../../OsekLib/: counter.c counter.h os.h OsTypes.h hook.c OsekLib.lib
    ../../OsekLib/startup/: keilUvisoin_startup.s
    ./: OsekIntroII_Example5.c
  group ECUAbstraction
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU2/BSW/ECU_Abstraction/: CanIf.c CanIf.h CanIf_Types.h IoHwAb_EngineTempActuator.c IoHwAb_EngineTempActuator.h
  group MCAL
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU2/BSW/MCAL/: CanDriver.c CanDriver.h Dio.c Dio.h MemMap.h Pwm.c Pwm.h
  group Services
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU2/BSW/Services/: Com.c Com.h PDU_R.c PDU_R.h
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU1/BSW/Services/: Dem.h Dem.c
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU1/BSW/MCAL/: Det.c Det.h
  group RTE
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU2/RTE/: Rte_EngineTemperatureActuator.c Rte_EngineTemperatureActuator.h EngineTemp_Types.h
  group common
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU2/common/: Compiler.h Compiler_Cfg.h Std_Types.h
  group SWC
    ../../../../../Mock_Autosar_Project/EngineCoolingSystem/ECU2/SWC/: EngineTemperatureActuator.c EngineTemperatureActuator.h
software components: CMSIS:CORE 6.1.0
